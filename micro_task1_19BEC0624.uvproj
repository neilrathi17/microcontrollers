# Keil uVision project micro_task1_19BEC0624.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C51RB2Hxx NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: micro_task1_19BEC0624
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: STARTUP.A51 trial.ASM
